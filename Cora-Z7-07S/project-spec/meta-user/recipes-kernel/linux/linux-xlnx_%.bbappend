SRC_URI += "file://no-uboot.cfg \
            file://security.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


